SUMMARY = "Single-axis ADCS flight software (Rust)"
HOMEPAGE = "https://github.com/mattheworris/adcs-testbed"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=cdfb7136ec49ba60c661157df7df0720"

# Change the URL/branch to wherever you push the repo.
SRC_URI = "git://github.com/mattheworris/adcs-testbed.git;protocol=https;branch=main \
           file://adcs-fsw.init \
           file://adcs-fsw.service \
           file://adcs-fsw.default \
          "
SRCREV = "${AUTOREV}"
PV = "0.1+git"
# Whinlatter: git sources unpack to ${UNPACKDIR}/${BP}, which is already the
# default S. Do not set S = "${WORKDIR}/git" (that is now an error).

inherit cargo cargo-update-recipe-crates update-rc.d systemd

# Build the fsw/ member of the workspace. The lockfile lives at the
# workspace root, so point the crate updater there.
CARGO_SRC_DIR = "fsw"
CARGO_LOCK_SRC_DIR = "${S}"

# Generated by: bitbake -c update_crates adcs-fsw
# (an empty placeholder ships so the recipe parses the first time)
require ${BPN}-crates.inc

# Works with either init manager; the classes install whichever applies.
INITSCRIPT_NAME = "adcs-fsw"
INITSCRIPT_PARAMS = "defaults 90 10"
SYSTEMD_SERVICE:${PN} = "adcs-fsw.service"

do_install:append() {
    install -d ${D}${sysconfdir}/default
    install -m 0644 ${UNPACKDIR}/adcs-fsw.default ${D}${sysconfdir}/default/adcs-fsw
    if ${@bb.utils.contains('DISTRO_FEATURES', 'systemd', 'true', 'false', d)}; then
        install -d ${D}${systemd_system_unitdir}
        install -m 0644 ${UNPACKDIR}/adcs-fsw.service ${D}${systemd_system_unitdir}/adcs-fsw.service
    fi
    if ${@bb.utils.contains('DISTRO_FEATURES', 'sysvinit', 'true', 'false', d)}; then
        install -d ${D}${sysconfdir}/init.d
        install -m 0755 ${UNPACKDIR}/adcs-fsw.init ${D}${sysconfdir}/init.d/adcs-fsw
    fi
}
